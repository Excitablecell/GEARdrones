# Keil uVision project GEARDRONE-F4.uvprojx, settings and files
target GEARDRONE-F4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: GEARDRONE-F4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --cpp11
  c include: ../Core/Inc;                        ../Drivers/STM32F4xx_HAL_Driver/Inc;                        ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                        ../Middlewares/Third_Party/FreeRTOS/Source/include;                        ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                        ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                        ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                        ../Drivers/CMSIS/Include;                        ..\GearLL;                        ..\GearLL\Applications;                        ..\GearLL\Middlewares;                        ..\GearLL\Drivers;                        ..\GearLL\Middlewares\Algorithm;                        ..\GearLL\Middlewares\Filter;                        ..\GearLL\Middlewares\Module;                        ..\GearLL\Middlewares\UpperMonitor;                        ..\GearLL\Drivers\Components;                        ..\GearLL\Drivers\Devices;                        ..\GearLL\Drivers\Devices\MPU6050;                        ..\GearLL\Drivers\Devices\TOF;                        ..\GearLL\Drivers\Devices\UWB;                        ..\GearLL\Applications\Services;                        ..\GearLL\Applications\System;                        ..\Drivers\CMSIS\DSP\Include;                        ..\Middlewares\SEGGER
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Segger
    ../Middlewares/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
  group GearLL/Applications/System
    ../GearLL/Applications/System/: System_Startup.cpp System_State.cpp
    ../GearLL/: GearLL_config.h
  group GearLL/Applications/Services
    ../GearLL/Applications/Services/: Services_Sensors.cpp Services_Drone.cpp Services_Communication.cpp
  group GearLL/Middlewares/Module
    ../GearLL/Middlewares/Module/: Sensors.cpp Drone.cpp Advanced_Dynamic_Model.cpp
  group GearLL/Middlewares/Filter
    ../GearLL/Middlewares/Filter/: filter.cpp
  group GearLL/Middlewares/Algorithm
    ../GearLL/Middlewares/Algorithm/: PID.cpp NLR_localization.cpp NLR_localization.h
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group GearLL/Middlewares/UpperMonitor
    ../GearLL/Middlewares/UpperMonitor/: UpperMonitor.cpp
  group GearLL/Drivers/Devices
    ../GearLL/Drivers/Devices/: SPL06_001.cpp HMC5883L.cpp HMC5883L.h BAT_VOLTAGE.h MPU.h OPTICFLOW.h TOF.h UWB.h ESP12F.cpp ESP12F.h Serial_Remote.h Light.h
  group GearLL/Drivers/Components
    ../GearLL/Drivers/Components/: i2c_def.c i2c_soft.c i2c_soft_mpu.c timer_driver.c flash_driver.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/vl53l0x
    ../GearLL/Drivers/Devices/TOF/: vl53l0x.c vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_gen.c vl53l0x_i2c.c vl53l0x_platform.c
  group Drivers/mpu6050
    ../GearLL/Drivers/Devices/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
  group Drivers/uwb
    ../GearLL/Drivers/Devices/UWB/: nlink_linktrack_nodeframe0.c nlink_linktrack_nodeframe2.c nlink_linktrack_nodeframe3.c nlink_linktrack_tagframe0.c nlink_utils.c
software components: CMSIS:CORE 4.3.0
