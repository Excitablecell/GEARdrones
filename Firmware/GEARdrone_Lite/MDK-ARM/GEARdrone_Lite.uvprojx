# Keil uVision project GEARdrone_Lite.uvprojx, settings and files
target GEARdrone_Lite (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GEARdrone_Lite +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,ARM_MATH_CM3,STM32_THREAD_SAFE_STRATEGY
  c include: ../Inc;..\MDK-ARM;../Drivers/CMSIS/Include;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\Middlewares;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;..\Middlewares\Module;..\Middlewares\Filter;..\Middlewares\DSP;..\Middlewares\DSP\Include;..\HardWare;..\HardWare\VL53L1\core;..\HardWare\VL53L1\platform;..\HardWare\UWB;..\HardWare\MPU6050;..\HardWare\SPL06;..\Applications
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x15000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/Tasks
    ../Applications/: ControlTask.cpp DataTask.cpp MonitorTask.cpp TOFTask.cpp System_Config.h
  group Application/User
    ../Src/: main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Middlewares/Module
    ../Middlewares/: Controller.cpp Drone.h
    ../Middlewares/Module/: PID.cpp i2c_mpu.c i2c_soft.c
    ../Middlewares/Filter/: filter.cpp
    ../HardWare/: flash.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ./: startup_stm32f103xb.s
    ../Src/: system_stm32f1xx.c
  group Drivers/uwb
    ../HardWare/: UWB.h
    ../HardWare/UWB/: nlink_linktrack_nodeframe0.c nlink_linktrack_nodeframe2.c nlink_linktrack_nodeframe3.c nlink_linktrack_tagframe0.c nlink_utils.c
  group Drivers/Magsensor
    ../HardWare/: HMC5883L.cpp
  group Drivers/mpu6050
    ../HardWare/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
  group Drivers/barometer
    ../HardWare/SPL06/: SPL06_001.cpp
  group Drivers/VL53L1
    ../HardWare/VL53L1/core/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_error_strings.c vl53l1_register_funcs.c vl53l1_silicon_core.c vl53l1_wait.c
    ../HardWare/VL53L1/platform/: vl53l1_platform.c vl53l1x.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0
